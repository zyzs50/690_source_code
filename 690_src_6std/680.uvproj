# Keil uVision project 680.uvproj, settings and files
target stm32_front (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 680 +hex
  c flags: Optim=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Lib\inc;.\System;.\USR;.\UCOSII\CONFIG;.\UCOSII\CORE;.\UCOSII\PORT;.\USB\LIB;.\USB\SRC;.\USB\USB_Public_data
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group ASM
    ./ASM/: startup_stm32f10x_hd.s
  group LIB
    ./Lib/SRC/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c
  group System
    ./System/: core_cm3.c system_stm32f10x.c
  group USR
    ./USR/: main.c pbdata.c stm32f10x_it.c motor.c uart.c ad.c func.c crc32.c ds18b20.c heat.c usb_config.c calibrate.c flash.c
  group uCOS-II/PORT
    ./UCOSII/PORT/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group uCOS-II/CORE
    ./UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-II/CONFIG
    ./UCOSII/CONFIG/: includes.h os_cfg.h
  group USB/SRC
    ./USB/SRC/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_it.c usb_prop.c usb_pwr.c
  group USB/LIB
    ./USB/LIB/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB/public
    ./USB/USB_Public_data/: Queue.c
